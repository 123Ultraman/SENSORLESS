# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0-dev0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G474QETx/STCubeGenerated/Src/: main.c stm32g4xx_it.c
    ./RTE/Device/STM32G474QETx/STCubeGenerated/Inc/: stm32g4xx_it.h
  group Documentation
    ./: Abstract.txt
target Release (6210000::V6.21::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0-dev0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Buttons 1.0.0, Board Support:Drivers:BUS 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:I/O 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:STM32CubeMX 1.5.2, Device:STM32Cube HAL 1.5.2
